# Keil uVision project ucostest.uvprojx, settings and files
target uCOSII-Test (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucostest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\App;..\BSP;..\BSP\FWLib\inc;..\ucosii\Source;..\ucosii\Ports;..\BSP\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartCode
    ../BSP/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../BSP/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../BSP/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ../App/: app.c app.h app_cfg.h includes.h os_cfg.h
  group BSP
    ../BSP/: bsp.c stm32f10x_conf.h stm32f10x_it.c bsp.h
  group uCOS-II/Ports
    ../ucosii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ../ucosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
